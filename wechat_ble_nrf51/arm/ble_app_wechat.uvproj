# Keil uVision project ble_app_wechat.uvproj, settings and files
target nrf51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_wechat +hex
  c flags: Optim=1 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BOARD_PCA10001 CATCH_LOG
  c misc: --c99
  c include: ..;..\services;..\services\products;..\services\common;..\source;..\libs;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;.\_build;..\Include;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\ble\softdevice
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group startup
    ../startup/: arm_startup_nrf51.s system_nrf51.c
  group services
    ../services/: ble_wechat_service.c
  group libs
    ../libs/: ble_stack_handler.c ble_conn_params.c ble_bondmngr.c ble_advdata.c app_timer.c app_gpiote.c app_button.c ble_flash.c ble_radio_notification.c nrf_delay.c crc16.c ble_srv_common.c ble_error_log.c ble_debug_assert_handler.c app_uart_fifo.c app_fifo.c twi_sw_master.c nrf_ecb.c
  group products
    ../services/products/: mpbledemo2.c
  group source
    ../source/: led.c main.c comsource.c
  group common
    ../services/common/: ble_wechat_util.c epb.c epb_MmBp.c
    ../source/: md5.c aes.c crc32.c
